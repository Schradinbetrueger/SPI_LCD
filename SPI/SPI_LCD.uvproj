# Keil uVision project SPI_LCD.uvproj, settings and files
target CM3_SPI_LCD (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SPI_LCD
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: STM32F10x.s armv10_std.h
  group Source
    ./: SPI_LCD.c
  group Library
    ./: ARMV10_STD.lib
